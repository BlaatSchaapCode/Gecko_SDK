# IAR project rtx_tickless.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\util\third_party\keil_rtx\Inc; ..\..\..\..\..\hardware\kit\EFM32GG_STK3700\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32GG990F1024
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtx_tickless.bin
  ILINK.IlinkOutputFile: rtx_tickless.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\util\third_party\keil_rtx\LIB\IAR\RTX_CM3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_lcd.c em_rtc.c em_system.c
  group Source
    ../: rtx_tickless.c RTX_Conf_CM.c
