# IAR project efr32.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: $--partNumber--$ SiliconLaboratories $--partNumber--$
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES$--partHardware.series--$_CONFIG$--partHardware.device_configuration--$_MICRO; PHY_RAIL; $--chipFamily;U--$; $--partNumber--$; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\rf4ce\include; $--frameworkDirFromProjBs--$\..\util; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\micro\cortexm3\efm32; $--halDirFromProjBs--$\micro\cortexm3\efm32\config; $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32; $--halDirFromProjBs--$\..\..\$--cmsisDir--$\Include; $--halDirFromProjBs--$\..\..\$--deviceDir--$\SiliconLabs\$--chipFamily--$\Include; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\common\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\config; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\dmadrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\ecode; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\gpiointerrupt\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\rtcdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\sleep\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\spidrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\tempdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\uartdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\ustimer\inc; $--halDirFromProjBs--$\..\..\$--emlibDir--$\inc; $--halDirFromProjBs--$\..\..\middleware\$--glibDir--$; $--halDirFromProjBs--$\..\..\middleware\$--glibDir--$\glib; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\chip\efr32\rf\common\cortex; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\chip\efr32\rf\rfprotocol\ieee802154\cortex
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_RAIL; EFR32_SERIES$--partHardware.series--$_CONFIG$--partHardware.device_configuration--$_MICRO; $--chipFamily;U--$; $--partNumber--$; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\rf4ce\include; $--frameworkDirFromProjBs--$\..\util; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\micro\cortexm3\efm32; $--halDirFromProjBs--$\micro\cortexm3\efm32\config; $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32; $--halDirFromProjBs--$\..\..\$--cmsisDir--$\Include; $--halDirFromProjBs--$\..\..\$--deviceDir--$\SiliconLabs\$--chipFamily--$\Include; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\common\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\config; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\dmadrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\ecode; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\gpiointerrupt\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\rtcdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\rtcdrv\test; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\sleep\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\spidrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\tempdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\uartdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\ustimer\inc; $--halDirFromProjBs--$\..\..\$--emlibDir--$\inc; $--halDirFromProjBs--$\..\..\middleware\$--glibDir--$; $--halDirFromProjBs--$\..\..\middleware\$--glibDir--$\glib; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\chip\efr32\rf\common\cortex; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\chip\efr32\rf\rfprotocol\ieee802154\cortex
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  prebuild: $--deviceName--$-prebuild.bat $PROJ_DIR$
  postbuild: $--deviceName--$-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$'
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=$--flashSize--$; RAM_SIZE=$--ramSize--$; $--bootloader--$=1
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group emdrv
    $--halDirFromProjBs--$/../../$--emdrvDir--$/dmadrv/src/: dmadrv.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/gpiointerrupt/src/: gpiointerrupt.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/rtcdrv/src/: rtcdriver.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/sleep/src/: sleep.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/spidrv/src/: spidrv.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/tempdrv/src/: tempdrv.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/uartdrv/src/: uartdrv.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/ustimer/src/: ustimer.c
  group emlib
    $--halDirFromProjBs--$/../../$--emlibDir--$/src/: em_adc.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    $--halDirFromProjBs--$/../../$--deviceDir--$/SiliconLabs/$--chipFamily;U--$/Source/: system_$--chipFamily;L--$.c
