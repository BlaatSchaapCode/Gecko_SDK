# IAR project em3xx.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_$--architectureId;U--$; PHY_EM3XX; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\rf4ce\include; $--frameworkDirFromProjBs--$\..\util; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\..\..\CMSIS\Include; $--halDirFromProjBs--$\..\..\$--deviceDir--$\SiliconLabs\$--chipFamily;L--$\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_$--architectureId;U--$; PHY_EM3XX; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  prebuild: $--deviceName--$-prebuild.bat $PROJ_DIR$
  postbuild: $--deviceName--$-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$'
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: $--bootloader--$=1
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\em35x\$--architectureId;L--$\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
